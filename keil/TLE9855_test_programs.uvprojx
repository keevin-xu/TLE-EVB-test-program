# Keil uVision project TLE9855_test_programs.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: TLE9855QX Infineon
  pack: Infineon.TLE985x_DFP.1.2.0
  cpu: IRAM(0x18000000,0x1000) IROM(0x11000000,0x18000) IROM2(0x10FFFFFC,4) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TLE9855_test_programs
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\include
  memory RVCT4: ROM 0x11000000 size 0x18000
  memory RVCT5: ROM 0x10fffffc size 0x4
  memory RVCT9: RAM 0x18000000 size 0x1000
  group Source Group 1
    ../src/: uart_hello_world.c
software components: CMSIS:CORE 6.2.0, Device:ConfigWizard_v2 2.1.12, Device:SDK:ADC1 0.2.9, Device:SDK:ADC2 0.3.5, Device:SDK:BDRV 0.3.1, Device:SDK:BOOTROM 0.2.5, Device:SDK:CCU6 0.3.1, Device:SDK:CSA 0.2.4, Device:SDK:GPT12E 0.2.4, Device:SDK:HS 0.2.5, Device:SDK:INT 0.3.1, Device:SDK:ISR 0.3.1, Device:SDK:LIN 0.2.5, Device:SDK:MATHDIV 0.2.5, Device:SDK:MON 0.2.5, Device:SDK:PMU 0.2.4, Device:SDK:PORT 0.2.4, Device:SDK:SCU 0.4.2, Device:SDK:SSC 0.2.4, Device:SDK:TIMER2x 0.2.4, Device:SDK:UART 0.2.6, Device:SDK:WDT1 0.2.5, Device:Startup 1.1.0
